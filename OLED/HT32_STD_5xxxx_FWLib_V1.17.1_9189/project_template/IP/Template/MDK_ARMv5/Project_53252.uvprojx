# Keil uVision project Project_53252.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F53252 Holtek
  pack: Holtek.HT32_DFP.1.0.67
  cpu: IROM(0x00000000-0x0001FBFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F53252_SK, USE_HT32F53242_52, USE_MEM_HT32F53252
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=28, USE_LIBCFG_RAM_SIZE=0x4000
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f5xxxx_01_it.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_15.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_15.s
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_can.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_ledc.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
software components: HT32 Stack Usage Analysis:HT32 Stack Usage Analysis 1.0.0
