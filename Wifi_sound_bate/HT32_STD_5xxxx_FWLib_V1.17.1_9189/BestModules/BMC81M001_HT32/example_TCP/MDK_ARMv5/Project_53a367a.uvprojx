# Keil uVision project Project_53a367a.uvprojx, settings and files
target HT32 (6230000::V6.23::ARMCLANG)
  device: HT32F52367 Holtek
  pack: Holtek.HT32_DFP.1.0.72
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x20007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HT32_DRIVER, USE_BM53A367A_DVB, USE_HT32F52357_67, USE_MEM_HT32F52367
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities;..\..\src;..\..\src\usb
  asm define: USE_HT32_CHIP=11, USE_LIBCFG_RAM_SIZE=0x8000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f5xxxx_01_it.c
    ../../src/: BMC81M001.c BMV31T001.c delay.c
    ../../../../utilities/middleware/: i2c_master.c uart_module.c spi_module.c
    ../../src/usb/: ht32_usbd_class.c ht32_usbd_descriptor.c usb_init.c USB_VCP.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_03.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_03.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_aes.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_dac.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
software components: HT32 Stack Usage Analysis:HT32 Stack Usage Analysis 1.0.0
